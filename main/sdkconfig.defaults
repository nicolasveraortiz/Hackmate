## main/sdkconfig.defaults
```kconfig
# put here your custom config value
CONFIG_FREERTOS_PLACE_FUNCTIONS_INTO_FLASH=y
CONFIG_ESP_WIFI_RX_IRAM_OPT=n
CONFIG_HEAP_PLACE_FUNCTION_INTO_FLASH=y
```
